Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Hockenheim\ECT-HOCK-0600-3C-000 + ECT-HOCK-0600-3-000 Hockenheim Box & Curved Grid Pattern .IFC
Time: 2024-11-20T16:40:35+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 549.1670234673090363; Volume Measure: 0.5491670234673097; Area Measure: 97.5190987406868999

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 549.1670234673090363; Volume Measure: 0.5491670234673097; Area Measure: 97.5190987406868999

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 549.1670234673090363; Volume Measure: 0.5491670234673097; Area Measure: 97.5190987406868999

# IfcBuildingElementProxy (45)
In: default BuildingStorey
Name
ECT-HOCK-0600-3C-000 + ECT-HOCK-0600-3-000 Hockenheim Box & Curved Grid Pattern .SLDPRT | PSet_Mass_Property - Mass Measure: 549.1670234673090363; Volume Measure: 0.5491670234673097; Area Measure: 97.5190987406868999
ECT-HOCK-0600-3-000 Hockenheim
ECT-HOCK-0600-3-000 Hockenheim-1
ECT-HOCK-0600-3-000 Hockenheim-2
ECT-HOCK-0600-3-000 Hockenheim-3
ECT-HOCK-0600-3-000 Hockenheim-4
ECT-HOCK-0600-3-000 Hockenheim-5
ECT-HOCK-0600-3-000 Hockenheim-6
ECT-HOCK-0600-3-000 Hockenheim-7
ECT-HOCK-0600-3-000 Hockenheim-8
ECT-HOCK-0600-3-000 Hockenheim-9
ECT-HOCK-0600-3-000 Hockenheim-10
ECT-HOCK-0600-3-000 Hockenheim-11
ECT-HOCK-0600-3-000 Hockenheim-12
ECT-HOCK-0600-3C-000 Hockenheim Curved Corner.SLDPRT
4 x ECT-HOCK-0600-3C-001 Hockenheim Curved Panel
4 x ECT-HOCK-0600-3C-002 Hockenheim Base + Side Panels
ECT-HOCK-0600-3C-000 Hockenheim Curved Corner.SLDPRT-1
ECT-HOCK-0600-3C-000 Hockenheim Curved Corner.SLDPRT-2
ECT-HOCK-0600-3-000 Hockenheim-13
ECT-HOCK-0600-3C-000 Hockenheim Curved Corner.SLDPRT-3
ECT-HOCK-0600-3-000 Hockenheim-14
ECT-HOCK-0600-3-000 Hockenheim-15
ECT-HOCK-0600-3-000 Hockenheim-16
ECT-HOCK-0600-3-000 Hockenheim-17
ECT-HOCK-0600-3-000 Hockenheim-18
ECT-HOCK-0600-3-000 Hockenheim-19
ECT-HOCK-0600-3-000 Hockenheim-20
ECT-HOCK-0600-3-000 Hockenheim-21
ECT-HOCK-0600-3-000 Hockenheim-22
ECT-HOCK-0600-3-000 Hockenheim-23
ECT-HOCK-0600-3-000 Hockenheim-24
ECT-HOCK-0600-3-000 Hockenheim-25
ECT-HOCK-0600-3-000 Hockenheim-26
ECT-HOCK-0600-3-000 Hockenheim-27
ECT-HOCK-0600-3-000 Hockenheim-28
ECT-HOCK-0600-3-000 Hockenheim-29
ECT-HOCK-0600-3-000 Hockenheim-30
ECT-HOCK-0600-3-000 Hockenheim-31
