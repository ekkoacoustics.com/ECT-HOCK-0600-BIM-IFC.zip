Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Hockenheim\ECT-HOCK-0600-2C-000 + ECT-HOCK-0600-2-000 Hockenheim Box & Curved Grid Pattern .IFC
Time: 2024-11-20T16:39:26+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 251.0244643338110961; Volume Measure: 0.2510244643338111; Area Measure: 44.8695287280416935

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 251.0244643338110961; Volume Measure: 0.2510244643338111; Area Measure: 44.8695287280416935

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 251.0244643338110961; Volume Measure: 0.2510244643338111; Area Measure: 44.8695287280416935

# IfcBuildingElementProxy (29)
In: default BuildingStorey
Name
ECT-HOCK-0600-2C-000 + ECT-HOCK-0600-2-000 Hockenheim Box & Curved Grid Pattern .SLDPRT | PSet_Mass_Property - Mass Measure: 251.0244643338110961; Volume Measure: 0.2510244643338111; Area Measure: 44.8695287280416935
ECT-HOCK-0600-2-000 Hockenheim
ECT-HOCK-0600-2-000 Hockenheim-1
ECT-HOCK-0600-2-000 Hockenheim-2
ECT-HOCK-0600-2-000 Hockenheim-3
ECT-HOCK-0600-2C-000 Hockenheim Curved Corner.SLDPRT
4 x ECT-HOCK-0600-2C-001 Hockenheim Curved Panel
4 x ECT-HOCK-0600-2C-002 Hockenheim Base + Side Panels
ECT-HOCK-0600-2C-000 Hockenheim Curved Corner.SLDPRT-1
ECT-HOCK-0600-2C-000 Hockenheim Curved Corner.SLDPRT-2
ECT-HOCK-0600-2C-000 Hockenheim Curved Corner.SLDPRT-3
ECT-HOCK-0600-2-000 Hockenheim-4
ECT-HOCK-0600-2-000 Hockenheim-5
ECT-HOCK-0600-2-000 Hockenheim-6
ECT-HOCK-0600-2-000 Hockenheim-7
ECT-HOCK-0600-2-000 Hockenheim-8
ECT-HOCK-0600-2-000 Hockenheim-9
ECT-HOCK-0600-2-000 Hockenheim-10
ECT-HOCK-0600-2-000 Hockenheim-11
ECT-HOCK-0600-2-000 Hockenheim-12
ECT-HOCK-0600-2-000 Hockenheim-13
ECT-HOCK-0600-2-000 Hockenheim-14
ECT-HOCK-0600-2-000 Hockenheim-15
