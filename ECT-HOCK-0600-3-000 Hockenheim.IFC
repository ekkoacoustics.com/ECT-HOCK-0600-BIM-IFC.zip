Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Hockenheim\ECT-HOCK-0600-3-000 Hockenheim.IFC
Time: 2024-11-20T16:43:04+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 15.4510320000000156; Volume Measure: 0.0154510320000000; Area Measure: 2.7440068881638027

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 15.4510320000000156; Volume Measure: 0.0154510320000000; Area Measure: 2.7440068881638027

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 15.4510320000000156; Volume Measure: 0.0154510320000000; Area Measure: 2.7440068881638027

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ECT-HOCK-0600-3-000 Hockenheim | PSet_Mass_Property - Mass Measure: 15.4510320000000156; Volume Measure: 0.0154510320000000; Area Measure: 2.7440068881638027
ECT-HOCK-0600-3-000 Hockenheim
