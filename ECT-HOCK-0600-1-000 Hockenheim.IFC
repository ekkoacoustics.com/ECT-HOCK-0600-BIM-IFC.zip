Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Hockenheim\ECT-HOCK-0600-1-000 Hockenheim.IFC
Time: 2024-11-20T16:41:50+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 10.2382320000000053; Volume Measure: 0.0102382320000000; Area Measure: 1.8480539877662399

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 10.2382320000000053; Volume Measure: 0.0102382320000000; Area Measure: 1.8480539877662399

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 10.2382320000000053; Volume Measure: 0.0102382320000000; Area Measure: 1.8480539877662399

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ECT-HOCK-0600-1-000 Hockenheim | PSet_Mass_Property - Mass Measure: 10.2382320000000053; Volume Measure: 0.0102382320000000; Area Measure: 1.8480539877662399
ECT-HOCK-0600-1-000 Hockenheim
