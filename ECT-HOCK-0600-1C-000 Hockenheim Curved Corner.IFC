Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Hockenheim\ECT-HOCK-0600-1C-000 Hockenheim Curved Corner.IFC
Time: 2024-11-20T16:38:49+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 9.0716763000782503; Volume Measure: 0.0090716763000782; Area Measure: 1.6388012804393484

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 9.0716763000782503; Volume Measure: 0.0090716763000782; Area Measure: 1.6388012804393484

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 9.0716763000782503; Volume Measure: 0.0090716763000782; Area Measure: 1.6388012804393484

# IfcBuildingElementProxy (3)
In: default BuildingStorey
Name
ECT-HOCK-0600-1C-000 Hockenheim Curved Corner.SLDPRT | PSet_Mass_Property - Mass Measure: 9.0716763000782503; Volume Measure: 0.0090716763000782; Area Measure: 1.6388012804393484
ECT-HOCK-0600-1C-002 Hockenheim Base + Side Panels.SLDPRT
ECT-HOCK-0600-1C-001 Hockenheim Curved Panel.SLDPRT
