Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Hockenheim\ECT-HOCK-0600-2-000 Hockenheim.IFC
Time: 2024-11-20T16:42:29+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 12.8446320000000149; Volume Measure: 0.0128446320000000; Area Measure: 2.2960304379650216

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 12.8446320000000149; Volume Measure: 0.0128446320000000; Area Measure: 2.2960304379650216

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 12.8446320000000149; Volume Measure: 0.0128446320000000; Area Measure: 2.2960304379650216

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ECT-HOCK-0600-2-000 Hockenheim | PSet_Mass_Property - Mass Measure: 12.8446320000000149; Volume Measure: 0.0128446320000000; Area Measure: 2.2960304379650216
ECT-HOCK-0600-2-000 Hockenheim
