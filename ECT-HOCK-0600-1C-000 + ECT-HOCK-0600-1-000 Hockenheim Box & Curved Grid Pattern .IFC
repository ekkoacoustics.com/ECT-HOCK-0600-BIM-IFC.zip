Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Hockenheim\ECT-HOCK-0600-1C-000 + ECT-HOCK-0600-1-000 Hockenheim Box & Curved Grid Pattern .IFC
Time: 2024-11-20T16:38:07+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 148.9072572003130688; Volume Measure: 0.1489072572003130; Area Measure: 26.8837989871860366

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 148.9072572003130688; Volume Measure: 0.1489072572003130; Area Measure: 26.8837989871860366

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 148.9072572003130688; Volume Measure: 0.1489072572003130; Area Measure: 26.8837989871860366

# IfcBuildingElementProxy (24)
In: default BuildingStorey
Name
ECT-HOCK-0600-1C-000 + ECT-HOCK-0600-1-000 Hockenheim Box & Curved Grid Pattern .SLDPRT | PSet_Mass_Property - Mass Measure: 148.9072572003130688; Volume Measure: 0.1489072572003130; Area Measure: 26.8837989871860366
ECT-HOCK-0600-1-000 Hockenheim
ECT-HOCK-0600-1-000 Hockenheim-1
ECT-HOCK-0600-1-000 Hockenheim-2
ECT-HOCK-0600-1-000 Hockenheim-3
ECT-HOCK-0600-1-000 Hockenheim-4
ECT-HOCK-0600-1-000 Hockenheim-5
ECT-HOCK-0600-1-000 Hockenheim-6
ECT-HOCK-0600-1-000 Hockenheim-7
ECT-HOCK-0600-1-000 Hockenheim-8
ECT-HOCK-0600-1-000 Hockenheim-9
ECT-HOCK-0600-1-000 Hockenheim-10
ECT-HOCK-0600-1C-000 Hockenheim Curved Corner.SLDPRT
4 x ECT-HOCK-0600-1C-002 Hockenheim Base + Side Panels.SLDPRT
4 x ECT-HOCK-0600-1C-001 Hockenheim Curved Panel.SLDPRT
ECT-HOCK-0600-1C-000 Hockenheim Curved Corner.SLDPRT-1
ECT-HOCK-0600-1C-000 Hockenheim Curved Corner.SLDPRT-2
ECT-HOCK-0600-1C-000 Hockenheim Curved Corner.SLDPRT-3
