Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Hockenheim\ECT-HOCK-0600-2C-000 Hockenheim Curved Corner.IFC
Time: 2024-11-20T16:40:01+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 11.3775880834527161; Volume Measure: 0.0113775880834527; Area Measure: 2.0332604301503325

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 11.3775880834527161; Volume Measure: 0.0113775880834527; Area Measure: 2.0332604301503325

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 11.3775880834527161; Volume Measure: 0.0113775880834527; Area Measure: 2.0332604301503325

# IfcBuildingElementProxy (3)
In: default BuildingStorey
Name
ECT-HOCK-0600-2C-000 Hockenheim Curved Corner.SLDPRT | PSet_Mass_Property - Mass Measure: 11.3775880834527161; Volume Measure: 0.0113775880834527; Area Measure: 2.0332604301503325
ECT-HOCK-0600-2C-001 Hockenheim Curved Panel
ECT-HOCK-0600-2C-002 Hockenheim Base + Side Panels
